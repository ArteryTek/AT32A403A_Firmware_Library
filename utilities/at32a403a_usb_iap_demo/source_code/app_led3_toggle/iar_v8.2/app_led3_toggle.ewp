# IAR project app_led3_toggle.ewp, settings and files
configuration at_start_a403a (ARM, debug)
  General.OGChipSelectEditMenu: AT32A403AVGT7_v2 ArteryTek -AT32A403AVGT7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: AT32A403AVGT7; USE_STDPERIPH_DRIVER; AT_START_A403A_V1
  ICCARM.CCIncludePath2: ..\..\..\..\..\libraries\drivers\inc; ..\..\..\..\..\libraries\cmsis\cm4\core_support; ..\..\..\..\..\libraries\cmsis\cm4\device_support; ..\inc; ..\..\..\..\..\project\at32a403a_board; ..\..\..\..\..\middlewares\usbd_class\hid_iap; ..\..\..\..\..\middlewares\usbd_drivers\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: at32a403a_app_led3_toggle.bin
  ILINK.IlinkOutputFile: app_led3_toggle.out
  ILINK.IlinkIcfFile: AT32A403AxG.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group bsp
    ../../../../../project/at32a403a_board/: at32a403a_board.c
  group cmsis
    ../../../../../libraries/cmsis/cm4/device_support/startup/iar/: startup_at32a403a.s
    ../../../../../libraries/cmsis/cm4/device_support/: system_at32a403a.c
  group firmware
    ../../../../../libraries/drivers/src/: at32a403a_acc.c at32a403a_crc.c at32a403a_crm.c at32a403a_usart.c at32a403a_flash.c at32a403a_gpio.c at32a403a_misc.c at32a403a_usb.c
  group readme
    ../: readme.txt
  group usbd_class
    ../../../../../middlewares/usbd_class/hid_iap/: hid_iap_class.c hid_iap_desc.c
  group usbd_drivers
    ../../../../../middlewares/usbd_drivers/src/: usbd_core.c usbd_int.c usbd_sdr.c
  group user
    ../src/: at32a403a_clock.c at32a403a_int.c hid_iap_user.c main.c
