# Keil uVision project app_led4_toggle.uvprojx, settings and files
target at_start_a403a (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: -AT32A403AVGT7 ArteryTek
  pack: ArteryTek.AT32A403A_DFP.2.0.0
  cpu: IRAM(0x20000000,0x38000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: at32a403a_app_led4_toggle +hex
  AfterMake: fromelf.exe --bin --output .\Listings\@L.bin !L
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32A403AVGT7,USE_STDPERIPH_DRIVER,AT_START_A403A_V1
  c include: ..\inc;..\..\..\..\..\project\at32a403a_board;..\..\..\..\..\libraries\drivers\inc;..\..\..\..\..\libraries\cmsis\cm4\core_support;..\..\..\..\..\libraries\cmsis\cm4\device_support;..\..\..\..\..\middlewares\usbd_drivers\inc;..\..\..\..\..\middlewares\usbd_class\hid_iap
  memory RVCT4: ROM 0x8005000 size 0xfb000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group user
    ../src/: at32a403a_clock.c at32a403a_int.c hid_iap_user.c main.c
  group bsp
    ../../../../../project/at32a403a_board/: at32a403a_board.c
  group firmware
    ../../../../../libraries/drivers/src/: at32a403a_acc.c at32a403a_crc.c at32a403a_crm.c at32a403a_usart.c at32a403a_flash.c at32a403a_gpio.c at32a403a_misc.c at32a403a_usb.c
  group cmsis
    ../../../../../libraries/cmsis/cm4/device_support/: system_at32a403a.c
    ../../../../../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32a403a.s
  group usbd_drivers
    ../../../../../middlewares/usbd_drivers/src/: usbd_core.c usbd_int.c usbd_sdr.c
  group usbd_class
    ../../../../../middlewares/usbd_class/hid_iap/: hid_iap_class.c hid_iap_desc.c
  group readme
    ../: readme.txt
