# Keil uVision project freertos_demo.uvprojx, settings and files
target at_start_a403a_ac5 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: -AT32A403AVGT7 ArteryTek
  pack: ArteryTek.AT32A403A_DFP.2.0.0
  cpu: IRAM(0x20000000,0x38000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: at32a403a_freertos_ac5 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: AT32A403AVGT7,USE_STDPERIPH_DRIVER,AT_START_A403A_V1
  c include: ..\inc;..\..\..\libraries\drivers\inc;..\..\..\project\at32a403a_board;..\..\..\libraries\cmsis\cm4\device_support;..\..\..\libraries\cmsis\cm4\core_support;..\..\..\middlewares\freertos\source\include;..\..\..\middlewares\freertos\source\portable\memmang;..\..\..\middlewares\freertos\source\portable\rvds\ARM_CM4F
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group user
    ../src/: at32a403a_clock.c at32a403a_int.c main.c include_port.c
  group bsp
    ../../../project/at32a403a_board/: at32a403a_board.c
  group firmware
    ../../../libraries/drivers/src/: at32a403a_acc.c at32a403a_adc.c at32a403a_bpr.c at32a403a_can.c at32a403a_crc.c at32a403a_crm.c at32a403a_dac.c at32a403a_debug.c at32a403a_dma.c at32a403a_exint.c at32a403a_flash.c at32a403a_gpio.c at32a403a_i2c.c at32a403a_misc.c at32a403a_pwc.c at32a403a_rtc.c at32a403a_sdio.c at32a403a_spi.c at32a403a_tmr.c at32a403a_usart.c at32a403a_usb.c at32a403a_wdt.c at32a403a_wwdt.c at32a403a_xmc.c
  group cmsis
    ../../../libraries/cmsis/cm4/device_support/: system_at32a403a.c
    ../../../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32a403a.s
  group freertos
    ../../../middlewares/freertos/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../middlewares/freertos/source/portable/memmang/: heap_4.c
  group readme
    ../: readme.txt
target at_start_a403a_ac6 (6160000::V6.16::ARMCLANG)
  device: -AT32A403AVGT7 ArteryTek
  pack: ArteryTek.AT32A403A_DFP.2.0.0
  cpu: as above
  output: at32a403a_freertos_ac6 +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: AT32A403AVGT7,USE_STDPERIPH_DRIVER,AT_START_A403A_V1
  c include: ..\inc;..\..\..\libraries\drivers\inc;..\..\..\project\at32a403a_board;..\..\..\libraries\cmsis\cm4\device_support;..\..\..\libraries\cmsis\cm4\core_support;..\..\..\middlewares\freertos\source\include;..\..\..\middlewares\freertos\source\portable\memmang;..\..\..\middlewares\freertos\source\portable\GCC\ARM_CM4F
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
