# IAR project project_l0.ewp, settings and files
configuration at_start_a403a (ARM)
  General.OGChipSelectEditMenu: AT32A403AVGT7_v2 ArteryTek -AT32A403AVGT7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: AT32A403AVGT7; USE_STDPERIPH_DRIVER; AT_START_A403A_V1; ARM_MATH_CM4
  ICCARM.CCIncludePath2: ..\..\..\..\libraries\drivers\inc; ..\..\..\..\libraries\cmsis\cm4\device_support; ..\..\..\..\libraries\cmsis\cm4\core_support; ..\inc; ..\..\..\..\project\at32a403a_board
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: at32a403a_project_l0.hex
  postbuild: $TOOLKIT_DIR$\bin\isymexport.exe --edit "steering_file.txt" "$TARGET_PATH$" "fir_filter_symbol.o"
  ILINK.IlinkOutputFile: project_l0.out
  ILINK.IlinkIcfFile: AT32A403AxG_slib.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group bsp
    ../../../../project/at32a403a_board/: at32a403a_board.c
  group cmsis
    ../../../../libraries/cmsis/cm4/device_support/startup/iar/: startup_at32a403a.s
    ../../../../libraries/cmsis/cm4/device_support/: system_at32a403a.c
  group fir_filter
    ../src/: arm_fir_f32.c arm_fir_init_f32.c fir_coefficient.c fir_filter.c
  group firmware
    ../../../../libraries/drivers/src/: at32a403a_crm.c at32a403a_usart.c at32a403a_flash.c at32a403a_gpio.c at32a403a_misc.c
  group readme
    ../: readme.txt
  group user
    ../src/: arm_fir_data.c at32a403a_clock.c at32a403a_int.c main.c math_helper.c
