# IAR project extend_sram.ewp, settings and files
configuration extend_sram_224k (ARM)
  General.OGChipSelectEditMenu: AT32A403AVGT7_v2 ArteryTek -AT32A403AVGT7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: AT32A403AVGT7; USE_STDPERIPH_DRIVER; AT_START_A403A_V1; EXTEND_SRAM=0xFE
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\libraries\drivers\inc; ..\..\..\..\..\..\libraries\cmsis\cm4\core_support; ..\..\..\..\..\..\libraries\cmsis\cm4\device_support; ..\inc; ..\..\..\..\..\at32a403a_board
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: extend_sram.srec
  ILINK.IlinkOutputFile: extend_sram_224k.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration extend_sram_96k (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: AT32A403AVGT7; USE_STDPERIPH_DRIVER; AT_START_A403A_V1; EXTEND_SRAM=0xFF
  ILINK.IlinkOutputFile: extend_sram_96k.out
  group bsp
    ../../../../../at32a403a_board/: at32a403a_board.c
  group cmsis
    ./: startup_at32a403a_ext_ram.s
    ../../../../../../libraries/cmsis/cm4/device_support/: system_at32a403a.c
  group firmware
    ../../../../../../libraries/drivers/src/: at32a403a_crm.c at32a403a_flash.c at32a403a_gpio.c at32a403a_misc.c at32a403a_usart.c
  group readme
    ../: readme.txt
  group user
    ../src/: at32a403a_clock.c at32a403a_int.c main.c
