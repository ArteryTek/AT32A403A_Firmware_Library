# Keil uVision project nand.uvprojx, settings and files
target h27u1g8f2ctr (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: -AT32A403AVGT7 ArteryTek
  pack: ArteryTek.AT32A403A_DFP.2.0.0
  cpu: IRAM(0x20000000,0x38000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: nand +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: AT32A403AVGT7,USE_STDPERIPH_DRIVER,AT_START_A403A_V1,H27U1G8F2CTR
  c include: ..\..\..\..\..\..\..\libraries\drivers\inc;..\..\..\..\..\..\..\libraries\cmsis\cm4\core_support;..\..\..\..\..\..\..\libraries\cmsis\cm4\device_support;..\inc;..\..\..\..\..\..\at32a403a_board
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group user
    ../src/: main.c xmc_nand.c at32a403a_int.c at32a403a_clock.c
  group bsp
    ../../../../../../at32a403a_board/: at32a403a_board.c
  group firmware
    ../../../../../../../libraries/drivers/src/: at32a403a_gpio.c at32a403a_crm.c at32a403a_usart.c at32a403a_xmc.c at32a403a_misc.c
  group cmsis
    ../../../../../../../libraries/cmsis/cm4/device_support/: system_at32a403a.c
    ../../../../../../../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32a403a.s
  group readme
    ../: readme.txt
target k9gag08u0e (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: -AT32A403AVGT7 ArteryTek
  pack: ArteryTek.AT32A403A_DFP.2.0.0
  output: nand +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: AT32A403AVGT7,USE_STDPERIPH_DRIVER,AT_START_A403A_V1,K9GAG08U0E
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
