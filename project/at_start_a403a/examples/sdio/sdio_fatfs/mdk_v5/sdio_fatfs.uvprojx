# Keil uVision project sdio_fatfs.uvprojx, settings and files
target sdio_fatfs (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: -AT32A403AVGT7 ArteryTek
  pack: ArteryTek.AT32A403A_DFP.2.0.0
  cpu: IRAM(0x20000000,0x38000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: sdio_fatfs +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32A403AVGT7,USE_STDPERIPH_DRIVER,AT_START_A403A_V1
  c include: ..\..\..\..\..\..\libraries\drivers\inc;..\..\..\..\..\..\libraries\cmsis\cm4\core_support;..\..\..\..\..\..\libraries\cmsis\cm4\device_support;..\inc;..\..\..\..\..\at32a403a_board;..\..\..\..\..\..\middlewares\3rd_party\fatfs\source
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group user
    ../src/: at32a403a_clock.c at32a403a_int.c at32_sdio.c main.c diskio.c
  group bsp
    ../../../../../at32a403a_board/: at32a403a_board.c
  group firmware
    ../../../../../../libraries/drivers/src/: at32a403a_gpio.c at32a403a_misc.c at32a403a_sdio.c at32a403a_dma.c at32a403a_crm.c at32a403a_usart.c
  group cmsis
    ../../../../../../libraries/cmsis/cm4/device_support/: system_at32a403a.c
    ../../../../../../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32a403a.s
  group fatfs
    ../../../../../../middlewares/3rd_party/fatfs/source/: ff.c ffsystem.c ffunicode.c
  group readme
    ../: readme.txt
