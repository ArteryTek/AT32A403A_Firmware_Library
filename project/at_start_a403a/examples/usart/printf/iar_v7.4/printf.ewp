# IAR project printf.ewp, settings and files
configuration printf (ARM)
  General.OGChipSelectEditMenu: AT32A403AVGT7_v2 ArteryTek -AT32A403AVGT7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: AT32A403AVGT7; USE_STDPERIPH_DRIVER; AT_START_A403A_V1
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\libraries\drivers\inc; ..\..\..\..\..\..\libraries\cmsis\cm4\core_support; ..\..\..\..\..\..\libraries\cmsis\cm4\device_support; ..\inc; ..\..\..\..\..\at32a403a_board
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: printf.srec
  ILINK.IlinkOutputFile: printf.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group bsp
    ../../../../../at32a403a_board/: at32a403a_board.c
  group cmsis
    ../../../../../../libraries/cmsis/cm4/device_support/startup/iar/: startup_at32a403a.s
    ../../../../../../libraries/cmsis/cm4/device_support/: system_at32a403a.c
  group firmware
    ../../../../../../libraries/drivers/src/: at32a403a_crm.c at32a403a_gpio.c at32a403a_misc.c at32a403a_usart.c
  group readme
    ../: readme.txt
  group user
    ../src/: at32a403a_int.c at32a403a_clock.c main.c
