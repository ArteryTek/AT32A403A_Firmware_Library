# IAR project template.ewp, settings and files
configuration template (ARM, debug)
  General.OGChipSelectEditMenu: AT32A403AVGT7_v2 ArteryTek -AT32A403AVGT7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: AT32A403AVGT7; USE_STDPERIPH_DRIVER; AT_START_A403A_V1
  ICCARM.CCIncludePath2: ..\..\..\..\libraries\drivers\inc; ..\..\..\..\libraries\cmsis\cm4\core_support; ..\..\..\..\libraries\cmsis\cm4\device_support; ..\inc; ..\..\..\at32a403a_board
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: template.srec
  ILINK.IlinkOutputFile: template.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group bsp
    ../../../at32a403a_board/: at32a403a_board.c
  group cmsis
    ../../../../libraries/cmsis/cm4/device_support/startup/iar/: startup_at32a403a.s
    ../../../../libraries/cmsis/cm4/device_support/: system_at32a403a.c
  group firmware
    ../../../../libraries/drivers/src/: at32a403a_acc.c at32a403a_adc.c at32a403a_bpr.c at32a403a_can.c at32a403a_crc.c at32a403a_crm.c at32a403a_dac.c at32a403a_debug.c at32a403a_dma.c at32a403a_emac.c at32a403a_exint.c at32a403a_flash.c at32a403a_gpio.c at32a403a_i2c.c at32a403a_misc.c at32a403a_pwc.c at32a403a_rtc.c at32a403a_sdio.c at32a403a_spi.c at32a403a_tmr.c at32a403a_usart.c at32a403a_usb.c at32a403a_wdt.c at32a403a_wwdt.c at32a403a_xmc.c
  group readme
    ../: readme.txt
  group user
    ../src/: at32a403a_clock.c at32a403a_int.c main.c
