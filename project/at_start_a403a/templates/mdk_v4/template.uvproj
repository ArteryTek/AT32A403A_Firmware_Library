# Keil uVision project template.uvproj, settings and files
target tempate (ARM-ADS)
  device: -AT32A403AVGT7 ArteryTek
  cpu: IRAM(0x20000000-0x20037FFF) IROM(0x08000000-0x080FFFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: Template +hex
  c flags: Optim=1
  c define: AT32A403AVGT7,USE_STDPERIPH_DRIVER,AT_START_A403A_V1
  c include: ..\..\..\..\libraries\drivers\inc;..\..\..\..\libraries\cmsis\cm4\core_support;..\..\..\..\libraries\cmsis\cm4\device_support;..\inc;..\..\..\at32a403a_board
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group user
    ../src/: at32a403a_int.c at32a403a_clock.c main.c
  group bsp
    ../../../at32a403a_board/: at32a403a_board.c
  group cmsis
    ../../../../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32a403a.s
    ../../../../libraries/cmsis/cm4/device_support/: system_at32a403a.c
  group firmware
    ../../../../libraries/drivers/src/: at32a403a_acc.c at32a403a_adc.c at32a403a_bpr.c at32a403a_can.c at32a403a_crc.c at32a403a_crm.c at32a403a_dac.c at32a403a_debug.c at32a403a_dma.c at32a403a_emac.c at32a403a_exint.c at32a403a_flash.c at32a403a_gpio.c at32a403a_i2c.c at32a403a_misc.c at32a403a_pwc.c at32a403a_rtc.c at32a403a_sdio.c at32a403a_spi.c at32a403a_tmr.c at32a403a_usart.c at32a403a_usb.c at32a403a_wdt.c at32a403a_wwdt.c at32a403a_xmc.c
  group readme
    ../: readme.txt
